# Keil uVision project myucos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: myucos +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress 236
  c include: .\APP;.\uCOS-II\Source;.\uCOS-II\Ports;.\uC-CPU;.\uC-LIB\Source;.\uC-LIB\Ports;.\BSP;.\CMSIS\Core\CM3;.\Source\CMSIS\Core\CM3\startup\arm;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;.\STM32_ETH_Driver\inc;.\Utilities\STM32_EVAL;.\Utilities\STM32_EVAL\STM3210C_EVAL;.\Utilities\lwip-1.3.1\port;.\Utilities\lwip-1.3.1\src\include;.\Utilities\lwip-1.3.1\src\include\ipv4;.\Utilities\lwip-1.3.1\src\include\lwip;.\Utilities\efsl\include;.\Utilities\efsl\include\interface;.\Utilities\STM32_EVAL\LCD;.\GSM;.\FATFS_V0.08A\src;.\STM32_USB_HOST_Driver\inc;.\STM32_USB_HOST_Library\Core\inc;.\STM32_USB_HOST_Library\Class\MSC\inc;.\MSC;.\STM32_USB_HOST_Library\Class\HID\inc;.\APP\dsp;.\APP\flash;.\APP\server;.\APP\usart;.\APP\http;.\APP\sim900
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./APP/: main.c stm32f10x_it.c netconf.c usr_task.c usr_task.h app_cfg.h os_cfg.h
    ./Utilities/lwip-1.3.1/port/: server.c
  group BSP
    ./BSP/: bsp.c
  group uC-OS-II/Port
    ./uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/CPU
    ./uC-CPU/: cpu_c.c cpu_a.asm cpu.h
  group uC-OS-II/Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group CM3
    ./CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group STM32_ETH_Driver
    ./STM32_ETH_Driver/src/: stm32_eth.c
  group LwIP
    ./Utilities/lwip-1.3.1/port/: ethernetif.c
    ./Utilities/lwip-1.3.1/src/api/: tcpip.c api_lib.c netbuf.c netifapi.c netdb.c api_msg.c err.c
    ./Utilities/lwip-1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ./Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./Utilities/lwip-1.3.1/src/netif/: etharp.c
  group GSM
    ./GSM/: GSM_COM_Driver.c GSM_GB2312_Unicode.c GSM_Processes.C GSM_RXD.C GSM_TXD.C GSM.H GSM_Config.h GSM_GB2312_Unicode.h GSM_Processes.h GSM_RXD.H GSM_TXD.h GSM_Typedefine.h
  group FWLib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USR_FLASH
    ./APP/flash/: usr_flash.c usr_flash.h
  group USR_DSP
    ./APP/dsp/: usr_dsp.c usr_dsp.h
  group USR_USART
    ./APP/usart/: usr_usart2.c usr_usart2.h
  group USR_SERVER
    ./APP/server/: urlencode.c usr_server.c urlencode.h usr_netpacket.h usr_server.h
  group USR_HTTP
    ./APP/http/: usr_http.c usr_http.h usr_sim900.h usr_sim900.c
  group USR_SIM900
    ./APP/sim900/: gsm_base.c gsm_base.h gsm_core.c gsm_core.h gsm_driver.c gsm_driver.h gsm_gprs.c gsm_gprs.h gsm_sms.c gsm_sms.h gsm_type.h
